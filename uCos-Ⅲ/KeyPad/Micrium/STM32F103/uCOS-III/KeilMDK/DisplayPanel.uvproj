# Keil uVision project DisplayPanel.uvproj, settings and files
target KeyPad (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KeyPAD +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: ..\..\uCOS-III;..\..\uCOS-III\KeilMDK;..\..\BSP;..\..\BSP\Uart;..\..\BSP\KeilMDK;..\..\BSP\OS\uCOS-III;..\..\BSP\ST\STM32\inc;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\uCOS-III\Source;..\..\uCOS-III-USBD-LIB;..\..\BSP\Console;..\..\BSP\USB_library\inc;..\..\BSP\RTC;..\..\BSP\KeyParse
  library: MicroLIB
  memory RVCT4: ROM 0x8003800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../: app.c os_app_hooks.c app_cfg.h cpu_cfg.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
    ../../BSP/RTLocLib/inc/: config.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/Uart/: uart.c
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu.h cpu_a.asm
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/OS-III Source
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os.h os_type.h
  group KeyParse
    ../../BSP/KeyParse/: Key.c Disp.c
  group Display
    ../../BSP/Display/: display.c
  group Console
    ../../BSP/Console/: command.c getcmd.c string.c term.c printk.c
  group RTC
    ../../BSP/RTC/: RTC.c
  group STM32F10x_Lib
    ../../BSP/ST/STM32/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
